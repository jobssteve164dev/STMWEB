# Keil uVision project DOT.uvprojx, settings and files
target DOT (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DOT +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\DOT_COER;..\STM32F10x_FWLib\inc;..\DOT_HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\DOT_HARDWARE\IIC;..\DOT_HARDWARE\ENCODER;..\DOT_HARDWARE\OLED;..\DOT\show;..\DOT_HARDWARE\LED;..\DOT_HARDWARE\KEY;..\DOT_HARDWARE\ADC;..\DOT_HARDWARE\MOTOR;..\DOT_HARDWARE\TIMER;..\DOT_HARDWARE\USART3;..\DOT_HARDWARE\EXTI;..\DOT_HARDWARE\DataScope_DP;..\DOT\filter;..\DOT_HARDWARE\STMFLASH;..\DOT_HARDWARE\DMP;..\DOT_HARDWARE\MPU6050;..\DOT\CONTROL;..\DOT_HARDWARE\LCD;..\DOT_HARDWARE\VL53L0X\core\inc;..\DOT_HARDWARE\VL53L0X\platform\inc;..\DOT_HARDWARE\VL53L0X\demo;..\DOT_HARDWARE\USART2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c DOT.c
  group CORE
    ../DOT_COER/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../DOT_HARDWARE/ADC/: adc.c
    ../DOT_HARDWARE/ENCODER/: encoder.c
    ../DOT_HARDWARE/EXTI/: exti.c
    ../DOT_HARDWARE/IIC/: IOI2C.c
    ../DOT_HARDWARE/KEY/: key.c
    ../DOT_HARDWARE/MOTOR/: motor.c
    ../DOT_HARDWARE/OLED/: oled.c
    ../DOT_HARDWARE/TIMER/: timer.c
    ../DOT_HARDWARE/USART3/: usart3.c
    ../DOT_HARDWARE/MPU6050/: MPU6050.c
    ../DOT_HARDWARE/LCD/: lcd.c lcd_init.c
    ../DOT_HARDWARE/USART2/: usart2.c
  group DOT
    ../DOT/CONTROL/: control.c
    ../DOT/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../DOT/filter/: filter.c
    ../DOT/show/: show.c
  group VL53L0X
    ../DOT_HARDWARE/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../DOT_HARDWARE/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
  group VL53L0X_DEMO
    ../DOT_HARDWARE/VL53L0X/demo/: vl53l0x.c vl53l0x_gen.c vl53l0x_it.c vl53l0x_cali.c
software components: CMSIS:CORE 5.4.0
